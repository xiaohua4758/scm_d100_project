# Keil uVision project n76e_scm.uvproj, settings and files
target n76e (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: SCM_D100_CFG +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: .\Include;.\Common
  group Source Group 1
    ./Code/: main.c myfunction.c timer.c lcd.c button_app.c flash.c
  group Startup
    ./Startup/: STARTUP.A51
